# Keil uVision project fall-detection.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_compiler_5.06v7)
  device: MKL46Z256VLH4 NXP
  pack: NXP.MKL46Z4_DFP.10.0.3
  cpu: IRAM(0x1fffe000,0x8000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: accelerator
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group Source Group 1
    ./: main.c i2c.h i2c.c delay.c delay.h led.c led.h slcd.c slcd.h mma8451.c mma8451.h state.c state.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
